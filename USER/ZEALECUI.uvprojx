# Keil uVision project ZEALECUI.uvprojx, settings and files
target ZEALECUI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\IIC;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\SRAM;..\HARDWARE\TIMER;..\HARDWARE\24CXX;..\HARDWARE\TOUCH;..\HARDWARE\CAN;..\HARDWARE\TIMER;..\HARDWARE\IWDG;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\MALLOC;..\FWLIB\CMSIS\Include;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c VelocityForm.c
  group GUI
    ../GUI/: Cover.c Main_Window.c Record_Window.c Control_Panel.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TOUCH/: ctiic.c touch.c
    ../HARDWARE/LCD/: tftlcd.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_iwdg.c stm32f4xx_exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group DSP_Lib
    ../FWLIB/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../FWLIB/CMSIS/Include/: arm_math.h
  group EMWIN_Config
    ../EMWIN/STemWin/Config/: GUIConf.c GUIDRV_Template.c GUI_X_Touch_Analog.c LCDConf_FlexColor_Template.c
    ../EMWIN/STemWin/OS/: GUI_X_FreeRTOS.c
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: STemWin540_CM4_OS_Keil.lib
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/include/: FreeRTOSConfig.h FreeRTOS.h
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_1.c
  group MALLOC
    ../MALLOC/: malloc.c
